# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s DAC.c ADC.c Timer0.c Timer1.c Sound.c LCD.s Print.s SpaceInvaders.c ST7735.c tm4c123gh6pm.h Movement.c Movement.h Player.c Collision.c Enemy.c HpBar.c Roulette.c ResultsScreen.c CharSelect.c
  group ObjectCode
    ./: texas.o
